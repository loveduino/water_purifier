# IAR project Backup (2) of Project.ewp, settings and files
configuration bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030RC ST STM32F030RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_STM320518_EVAL; STM320518_EVAL_REVB
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32f0xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c
  group User
    ../src/: common.c flash_if.c main.c menu.c stm32f0xx_it.c ymodem.c
    ../: readme.txt
